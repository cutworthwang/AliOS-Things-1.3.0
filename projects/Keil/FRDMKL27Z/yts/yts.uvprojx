# Keil uVision project yts.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL27Z64VLH4 NXP
  pack: NXP.MKL27Z644_DFP.2.3.0
  cpu: IRAM(0x1ffff000,0x4000) IRAM2(0x400fe000,0x0200) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: aos_rhino
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_NO_TCPIP DEBUG, CPU_MKL27Z64VLH4, FRDM_KL27Z, FREEDOM VCALL_RHINO AOS_KV AOS_HAL HAVE_NOT_ADVANCED_FORMATE
  c misc: --diag_suppress=66,68,1296,186 -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.3.0\" -DSYSINFO_ARCH=\"Cortex-M0\" -DSYSINFO_MCU=\"mkl27z644\" -DTEST_CONFIG_KV_ENABLED=0  -DTEST_CONFIG_YLOOP_ENABLED=0  -DSYSINFO_DEVICE_NAME=\"MKL27Z644\"
  c include: ..\..\..\..\kernel\rhino\core\include;..\..\..\..\board\frdmkl27z;..\..\..\..\platform\arch\arm\armv6m\armcc\m0plus;..\..\..\..\platform\mcu\mkl27z644;..\..\..\..\platform\mcu\include;..\..\..\..\platform\mcu\mkl27z644\drivers;..\..\..\..\platform\mcu\mkl27z644\aos;..\..\..\..\include;..\..\..\..\kernel\rhino\test;..\..\..\..\include\hal\soc;..\..\..\..\include\aos\internal;..\..\..\..\include\aos;..\..\..\..\include;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\kernel\vfs\include;..\..\..\..\kernel\vfs\device;..\..\..\..\kernel\modules\fs\kv\include;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\test;..\..\..\..\test\yunit\include;..\..\..\..\test\testcase\certificate_test\cutest;..\..\..\..\test\testcase\include;..\..\..\..\utility\log
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  memory RVCT10: RAM 0x400fe000 size 0x200
  scatter file: ..\..\..\..\platform\mcu\mkl27z644\arm\MKL27Z64xxx4_flash.scf
  link misc: --diag_suppress=L6329
--remove
  group auto
    ./auto/: component_init.c testcase_register.c
  group kernel/rhino
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group board
    ../../../../board/frdmkl27z/: board.c clock_config.c pin_mux.c
  group platform/mcu/aos
    ../../../../platform/mcu/mkl27z644/aos/: aos.c soc_impl.c
  group plarform/arch
    ../../../../platform/arch/arm/armv6m/armcc/m0plus/: port_c.c port_s.s
  group platform/mcu/drivers
    ../../../../platform/mcu/mkl27z644/drivers/: fsl_clock.c fsl_common.c fsl_flash.c fsl_gpio.c fsl_lpuart.c fsl_smc.c fsl_uart.c
    ../../../../platform/mcu/mkl27z644/: system_MKL27Z644.c
    ../../../../platform/mcu/mkl27z644/arm/: startup_MKL27Z644.s
  group kernel/vcall
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group example
    ../../../../example/yts/: main.c
  group platform/hal
    ../../../../platform/mcu/mkl27z644/hal/: hal_uart.c hal_flash.c
  group kernel/kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel/vfs
    ../../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c
  group utility/libc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group test/testcase
    ../../../../test/testcase/certificate_test/cutest/: cut.c
    ../../../../test/testcase/: yts_main.c
    ../../../../test/testcase/certificate_test/: aos_test.c
  group test/yunit
    ../../../../test/yunit/: yunit.c
  group utility/log
    ../../../../utility/log/: log.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL27Z64VLH4 NXP
  pack: NXP.MKL27Z644_DFP.2.3.0
  cpu: as above
  output: aos_rhino
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_NO_TCPIP NDEBUG, CPU_MKL27Z64VLH4, FRDM_KL27Z, FREEDOM  VCALL_RHINO AOS_KV AOS_HAL HAVE_NOT_ADVANCED_FORMATE
  c misc: as above
  c include: ..\..\..\..\kernel\rhino\core\include;..\..\..\..\board\frdmkl27z;..\..\..\..\platform\arch\arm\armv6m\armcc\m0plus;..\..\..\..\platform\mcu\mkl27z644;..\..\..\..\platform\mcu\include;..\..\..\..\platform\mcu\mkl27z644\drivers;..\..\..\..\platform\mcu\mkl27z644\aos;..\..\..\..\platform\mcu\mkl27z644\utilities\debug_console;..\..\..\..\platform\mcu\mkl27z644\utilities\debug_console\io;..\..\..\..\platform\mcu\mkl27z644\utilities\debug_console\log;..\..\..\..\platform\mcu\mkl27z644\utilities\debug_console\str;..\..\..\..\include;..\..\..\..\kernel\rhino\test;..\..\..\..\include\hal\soc;..\..\..\..\include\aos\internal;..\..\..\..\include\aos;..\..\..\..\include;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\utility\log;..\..\..\..\test\testcase\certificate_test\cutest;..\..\..\..\test\yunit\include;..\..\..\..\test\testcase\include;..\..\..\..\kernel\vfs\device;..\..\..\..\kernel\vfs\include;..\..\..\..\kernel\modules\fs\kv\include
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  memory RVCT10: RAM 0x400fe000 size 0x200
  scatter file: as above
  link misc: --diag_suppress=L6329
--remove
software components: CMSIS:CORE 5.0.2
