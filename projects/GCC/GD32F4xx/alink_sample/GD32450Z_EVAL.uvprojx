# Keil uVision project GD32450Z_EVAL.uvprojx, settings and files
target GD32F450Z_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x0300000) IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32450Z_EVAL
  group Application
    ../../../../platform/mcu/gd32f4xx/src/alink_sample/: gd32f4xx_it.c main.c systick.c
    ../../../../example/alinkapp/: alink_sample.c
  group CMSIS
    ../../../../platform/mcu/gd32f4xx/driver/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../../../../platform/mcu/gd32f4xx/driver/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../../../../platform/mcu/gd32f4xx/driver/Utilities/: gd32f450z_eval.c
  group Startup
    ../../../../platform/mcu/gd32f4xx/startup/gcc/: startup_gd32f450.S
  group AliOS-Kernel-rhino
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../../kernel/init/: aos_init.c
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
  group AliOS-Kernel-vcal
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group AliOS-Kernel-Yloop
    ../../../../kernel/yloop/: local_event.c yloop.c
  group AliOS-Kernel-vfs
    ../../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c select.c vfs_file.c
  group AliOS-Port
    ../../../../platform/arch/arm/armv7m/gcc/m4/: k_types.h port.h port_c.c port_s.S
  group AliOS-SOC
    ../../../../platform/mcu/gd32f4xx/soc/: soc_impl.c soc_init.c trace_impl.c
  group AliOS-LIBC
    ../../../../utility/libc/: newlib_stub.c
  group AliOS-HAL
    ../../../../platform/mcu/gd32f4xx/hal/: flash_port.c ringbuf.c uart.c
    ../../../../kernel/hal/: wifi.c
    ../../../../board/gd32f4xx/: board.c
  group AliOS-CLI
    ../../../../tools/cli/: cli.c dumpsys.c
    ../../../../utility/log/: log.c
  group AliOS-potocal-Lwip
    ../../../../kernel/protocols/net/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../kernel/protocols/net/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../kernel/protocols/net/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../kernel/protocols/net/netif/: ethernet.c
  group AliOS-potocal-Lwip-port
    ../../../../kernel/protocols/net/port/: sys_arch.c
  group AliOS-Alink
    ../../../../framework/protocol/alink/accs/: accs.c alink_protocol.c
    ../../../../framework/protocol/alink/cota/: cota.c
    ../../../../framework/protocol/alink/json/: json_parser.c
    ../../../../framework/protocol/alink/os/: os.c os_misc.c os_thread.c
    ../../../../framework/protocol/alink/os/product/: product.c
    ../../../../framework/protocol/alink/system/: alink_export.c config.c device.c monitor.c
    ../../../../framework/protocol/alink/: service_manager.c
  group AliOS-Alink-port
    ../../../../framework/protocol/alink/os/platform/: aos_awss.c aos_hardware.c aos_network.c aos_os.c aos_ssl.c
  group AliOS-SSL
    ../../../../security/mbedtls/src/: mbedtls_alt.c mbedtls_net.c mbedtls_ssl.c
    ../../../../security/alicrypto/lib/Cortex-M4/: libalicrypto.a libmbedcrypto.a
    ../../../../security/mbedtls/lib/Cortex-M4/: libmbedtls.a
  group AliOS-Framework
    ../../../../framework/cloud/: cloud.c
    ../../../../framework/common/: version.c
    ../../../../framework/connectivity/wsf/: connectivity_manager.c wsf.c wsf_client.c wsf_config.c wsf_list.c wsf_msg.c wsf_msg_queue.c wsf_network.c wsf_ssl_cert.c wsf_worker.c
    ../../../../framework/netmgr/: netmgr.c
  group AliOS-Module
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group AliOS-Utility
    ../../../../utility/cjson/: cJSON.c
    ../../../../utility/digest_algorithm/: digest_algorithm.c md5.c crc.c
  group AliOS-ATcmd
    ../../../../framework/atparser/: atparser.c
    ../../../../tools/at_adapter/: at_adapter.c
    ../../../../device/sal/wifi/mk3060/: wifi_atcmd.c
software components: CMSIS:CORE 4.3.0
